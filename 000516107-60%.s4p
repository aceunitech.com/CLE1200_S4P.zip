!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:51:29
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S43: -0.1, -12.8, -25.8, -40.7, -49.5
!     S21: -0.1, -13.1, -26.1, -38.9, -66.7
!     S23: -50.7, -79.9, -62.4, -53.4, -48.6
!     S24: -59.3, -72.1, -55.9, -50.8, -45.2
!     S13: -54.0, -89.2, -60.1, -55.5, -47.9
!     S32: -59.0, -81.5, -59.0, -55.4, -70.1
!   lowest |S11| = -39.1 dB at 34.84 GHz (marker M1), VSWR 1.02, Z = 49.3 + j0.868 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S43  S21  S23  S24  S13  S32
! 10 MHz  -36.6  -0.1  -0.1  -50.7  -59.3  -54.0  -59.0
! 344.9 MHz  -24.9  -0.2  -0.3  -83.5  -75.6  -79.0  -77.3
! 34.84 GHz  -39.1  -27.0  -27.1  -62.1  -68.0  -57.5  -57.6
! 53.27 GHz  -23.4  -43.7  -43.5  -54.3  -72.7  -53.3  -62.0
! 56.62 GHz  -26.5  -44.6  -48.5  -54.2  -60.8  -60.1  -54.1
! 63.99 GHz  -20.8  -55.9  -61.2  -52.5  -58.1  -59.0  -63.5
! 67 GHz  -17.3  -49.5  -66.7  -48.6  -45.2  -47.9  -70.1
