!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:50:46
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S43: -0.1, -10.7, -21.5, -34.2, -48.9
!     S21: -0.1, -10.9, -22.2, -33.7, -49.7
!     S24: -50.0, -68.7, -53.0, -53.1, -62.2
!     S23: -61.5, -68.1, -58.6, -62.0, -45.2
!     S41: -55.0, -62.6, -58.7, -52.8, -48.2
!     S42: -60.4, -70.5, -56.8, -60.7, -57.6
!   lowest |S11| = -40.0 dB at 28.15 GHz (marker M1), VSWR 1.02, Z = 50.9 - j0.353 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S43  S21  S24  S23  S41  S42
! 10 MHz  -36.5  -0.1  -0.1  -50.0  -61.5  -55.0  -60.4
! 2.355 GHz  -25.1  -1.5  -1.5  -89.7  -78.8  -72.0  -85.2
! 28.15 GHz  -40.0  -18.2  -18.9  -62.4  -62.2  -60.2  -63.8
! 43.89 GHz  -37.7  -30.1  -28.4  -56.4  -66.2  -52.8  -57.1
! 62.65 GHz  -17.5  -54.7  -50.2  -59.2  -47.1  -52.7  -51.8
! 63.65 GHz  -32.2  -45.2  -57.9  -60.8  -74.1  -52.1  -52.1
! 67 GHz  -14.4  -48.9  -49.7  -62.2  -45.2  -48.2  -57.6
