!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:52:16
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.1, -15.0, -29.1, -44.8, -47.4
!     S43: 0.0, -14.7, -29.9, -42.7, -47.3
!     S31: -53.3, -72.4, -62.1, -52.5, -61.6
!     S32: -49.2, -74.9, -73.0, -68.9, -54.2
!     S14: -82.3, -80.1, -60.7, -49.1, -48.9
!     S42: -55.0, -73.3, -56.4, -64.4, -69.8
!   lowest |S11| = -52.1 dB at 52.26 GHz (marker M1), VSWR 1.01, Z = 50.2 - j0.0886 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S21  S43  S31  S32  S14  S42
! 10 MHz  -36.0  -0.1  0.0  -53.3  -49.2  -82.3  -55.0
! 1.35 GHz  -25.7  -1.3  -1.1  -70.6  -81.4  -72.3  -84.3
! 48.24 GHz  -18.3  -42.6  -43.4  -53.5  -66.0  -54.3  -55.0
! 51.93 GHz  -21.9  -49.1  -46.2  -57.1  -63.3  -51.3  -56.2
! 52.26 GHz  -52.1  -43.9  -48.1  -52.6  -60.1  -49.2  -54.4
! 52.93 GHz  -20.6  -45.5  -47.9  -53.1  -52.4  -64.4  -59.9
! 67 GHz  -14.2  -47.4  -47.3  -61.6  -54.2  -48.9  -69.8
