!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:49:59
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S43: -0.1, -8.8, -17.2, -28.0, -49.3
!     S21: -0.1, -8.9, -18.1, -29.5, -54.1
!     S42: -55.8, -70.2, -61.5, -51.5, -55.6
!     S13: -60.3, -72.9, -61.3, -66.8, -51.9
!     S41: -53.6, -71.6, -69.2, -63.8, -55.5
!     S31: -53.3, -71.2, -65.5, -64.4, -61.8
!   lowest |S11| = -49.3 dB at 27.81 GHz (marker M1), VSWR 1.01, Z = 50.3 - j0.0875 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S43  S21  S42  S13  S41  S31
! 10 MHz  -34.9  -0.1  -0.1  -55.8  -60.3  -53.6  -53.3
! 1.015 GHz  -24.7  -0.6  -0.5  -74.1  -72.9  -73.0  -69.3
! 11.4 GHz  -26.5  -6.1  -6.1  -75.4  -70.2  -74.2  -76.6
! 26.81 GHz  -21.9  -13.9  -14.7  -63.8  -62.3  -65.0  -61.1
! 27.81 GHz  -49.3  -14.3  -15.2  -61.4  -61.4  -62.3  -73.0
! 40.2 GHz  -22.2  -21.1  -22.1  -62.7  -55.5  -63.4  -60.3
! 67 GHz  -16.6  -49.3  -54.1  -55.6  -51.9  -55.5  -61.8
