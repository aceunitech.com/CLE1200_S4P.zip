!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:53:01
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.1, -17.1, -33.3, -54.3, -61.8
!     S43: 0.0, -16.8, -34.0, -53.0, -50.4
!     S24: -67.0, -71.3, -67.8, -56.8, -46.5
!     S32: -64.2, -82.4, -57.1, -64.9, -62.5
!     S41: -56.9, -72.2, -60.3, -54.0, -56.3
!     S31: -56.3, -71.3, -64.1, -54.6, -51.3
!   lowest |S11| = -41.6 dB at 28.15 GHz (marker M1), VSWR 1.02, Z = 50.2 + j0.815 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S21  S43  S24  S32  S41  S31
! 10 MHz  -36.5  -0.1  0.0  -67.0  -64.2  -56.9  -56.3
! 344.9 MHz  -20.5  -0.4  -0.3  -72.6  -72.4  -77.5  -73.4
! 2.69 GHz  -14.0  -3.2  -2.9  -79.0  -67.2  -75.6  -77.3
! 28.15 GHz  -41.6  -29.1  -28.2  -55.9  -58.7  -65.9  -74.4
! 57.62 GHz  -15.0  -52.9  -51.5  -52.8  -57.7  -49.0  -58.2
! 63.32 GHz  -18.6  -55.8  -57.3  -51.2  -57.8  -49.0  -64.2
! 67 GHz  -18.5  -61.8  -50.4  -46.5  -62.5  -56.3  -51.3
