!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:46:08
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S43: -0.1, -3.0, -6.0, -11.4, -36.1
!     S21: -0.1, -3.1, -6.1, -13.1, -31.3
!     S32: -50.7, -72.3, -61.8, -57.0, -56.3
!     S41: -59.8, -71.4, -58.8, -47.7, -59.8
!     S31: -61.2, -73.4, -56.8, -54.9, -57.3
!     S42: -51.7, -78.6, -61.3, -55.6, -61.5
!   lowest |S11| = -44.6 dB at 37.19 GHz (marker M1), VSWR 1.01, Z = 49.8 - j0.55 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S43  S21  S32  S41  S31  S42
! 10 MHz  -34.6  -0.1  -0.1  -50.7  -59.8  -61.2  -51.7
! 1.015 GHz  -32.6  -0.3  -0.3  -74.0  -70.5  -88.6  -84.1
! 37.19 GHz  -44.6  -6.7  -6.9  -62.2  -60.7  -58.2  -55.7
! 58.96 GHz  -18.5  -23.4  -29.6  -53.1  -58.2  -62.0  -49.5
! 61.31 GHz  -14.9  -22.8  -26.8  -51.2  -49.8  -54.7  -55.6
! 65.66 GHz  -19.7  -32.5  -47.1  -53.1  -59.2  -51.8  -57.0
! 67 GHz  -16.3  -36.1  -31.3  -56.3  -59.8  -57.3  -61.5
