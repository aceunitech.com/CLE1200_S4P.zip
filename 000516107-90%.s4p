!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:53:57
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.1, -19.0, -36.6, -49.9, -48.0
!     S43: 0.0, -19.0, -38.9, -61.4, -51.2
!     S14: -49.3, -71.3, -63.3, -53.1, -58.8
!     S31: -62.4, -74.7, -68.7, -56.2, -60.9
!     S32: -53.4, -75.9, -56.6, -56.9, -59.0
!     S42: -53.1, -76.7, -67.1, -57.1, -56.1
!   lowest |S11| = -39.0 dB at 18.43 GHz (marker M1), VSWR 1.02, Z = 49 - j0.495 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S21  S43  S14  S31  S32  S42
! 10 MHz  -37.3  -0.1  0.0  -49.3  -62.4  -53.4  -53.1
! 1.015 GHz  -19.3  -1.3  -1.2  -82.3  -67.5  -71.1  -70.2
! 15.42 GHz  -26.4  -17.6  -17.6  -74.8  -69.8  -70.7  -66.9
! 18.43 GHz  -39.0  -20.9  -20.7  -71.1  -73.7  -81.3  -72.7
! 46.23 GHz  -21.7  -51.4  -55.6  -62.6  -62.8  -58.9  -57.9
! 58.96 GHz  -20.2  -47.1  -57.1  -50.6  -50.8  -47.5  -54.3
! 67 GHz  -13.3  -48.0  -51.2  -58.8  -60.9  -59.0  -56.1
