!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:41:34
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S43: 0.0, -1.1, -1.9, -5.4, -26.0
!     S21: -0.1, -1.1, -2.2, -4.1, -21.1
!     S24: -48.2, -70.8, -53.5, -58.5, -53.9
!     S23: -50.9, -68.9, -56.4, -53.9, -49.3
!     S42: -53.3, -74.7, -62.9, -62.6, -71.0
!     S31: -57.2, -76.3, -61.1, -60.6, -49.1
!   lowest |S11| = -57.1 dB at 16.76 GHz (marker M1), VSWR 1.00, Z = 49.9 + j0.0982 ohm
!   |S11| at or under -10 dB: start of sweep to 57.26 GHz; 57.32 GHz to 59.59 GHz (2.276 GHz wide, 3.89 % of centre); 59.65 GHz to end of sweep
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! magnitudes (dB):
! f  S11  S43  S21  S24  S23  S42  S31
! 10 MHz  -34.7  0.0  -0.1  -48.2  -50.9  -53.3  -57.2
! 16.09 GHz  -23.6  -1.1  -1.1  -74.7  -72.9  -67.4  -78.4
! 16.76 GHz  -57.1  -1.1  -1.1  -70.8  -68.9  -74.7  -76.3
! 21.45 GHz  -19.8  -1.4  -1.4  -83.6  -85.4  -73.3  -74.3
! 23.46 GHz  -34.1  -1.4  -1.5  -73.0  -67.8  -72.2  -68.1
! 28.48 GHz  -18.3  -1.7  -1.9  -58.7  -59.0  -61.9  -59.9
! 67 GHz  -14.8  -26.0  -21.1  -53.9  -49.3  -71.0  -49.1
