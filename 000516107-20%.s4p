!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:48:06
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S43: 0.0, -4.9, -9.5, -16.3, -34.6
!     S21: -0.1, -5.0, -10.2, -19.3, -39.2
!     S23: -56.7, -68.5, -59.3, -68.4, -50.5
!     S32: -66.3, -72.4, -57.6, -55.8, -53.5
!     S42: -56.7, -70.6, -56.5, -67.3, -79.0
!     S31: -48.1, -76.4, -52.1, -62.6, -54.8
!   lowest |S11| = -43.5 dB at 9.389 GHz (marker M1), VSWR 1.01, Z = 49.5 - j0.472 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S43  S21  S23  S32  S42  S31
! 10 MHz  -34.6  0.0  -0.1  -56.7  -66.3  -56.7  -48.1
! 344.9 MHz  -36.5  -0.1  -0.1  -72.0  -85.3  -84.5  -78.3
! 9.389 GHz  -43.5  -2.9  -2.9  -84.9  -76.6  -78.7  -82.1
! 51.26 GHz  -25.1  -17.5  -19.0  -55.5  -56.1  -46.7  -64.1
! 56.95 GHz  -24.3  -23.4  -27.6  -57.9  -49.4  -76.2  -49.3
! 62.98 GHz  -23.8  -27.9  -38.7  -57.7  -50.1  -45.2  -52.9
! 67 GHz  -16.1  -34.6  -39.2  -50.5  -53.5  -79.0  -54.8
