!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:54:53
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S21: -0.1, -21.2, -40.9, -57.2, -49.6
!     S43: 0.0, -21.1, -44.4, -60.2, -48.4
!     S23: -63.3, -81.5, -65.3, -51.1, -53.5
!     S41: -51.5, -77.3, -63.1, -53.1, -58.5
!     S42: -52.3, -70.2, -59.7, -59.1, -59.9
!     S31: -50.1, -76.7, -55.1, -55.8, -53.2
!   lowest |S11| = -41.9 dB at 35.51 GHz (marker M1), VSWR 1.02, Z = 49.5 - j0.629 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S21  S43  S23  S41  S42  S31
! 10 MHz  -35.8  -0.1  0.0  -63.3  -51.5  -52.3  -50.1
! 344.9 MHz  -17.6  -0.5  -0.4  -76.4  -68.8  -74.3  -68.2
! 19.44 GHz  -24.5  -24.3  -24.2  -71.5  -77.5  -70.2  -66.4
! 21.45 GHz  -25.1  -26.9  -26.6  -72.8  -76.5  -72.3  -77.1
! 35.51 GHz  -41.9  -42.6  -45.2  -58.4  -67.1  -62.1  -66.1
! 43.22 GHz  -17.9  -48.8  -83.7  -54.7  -55.3  -49.0  -60.7
! 67 GHz  -16.0  -49.6  -48.4  -53.5  -58.5  -59.9  -53.2
