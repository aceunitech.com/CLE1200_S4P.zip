!Keysight Technologies,N5247A,US50470101,A.10.64.03
!Date: Friday, September 14, 2018 14:49:08
!Correction: S11(Full 4 Port(1,2,3,4))
!S12(Full 4 Port(1,2,3,4))
!S13(Full 4 Port(1,2,3,4))
!S14(Full 4 Port(1,2,3,4))
!S21(Full 4 Port(1,2,3,4))
!S22(Full 4 Port(1,2,3,4))
!S23(Full 4 Port(1,2,3,4))
!S24(Full 4 Port(1,2,3,4))
!S31(Full 4 Port(1,2,3,4))
!S32(Full 4 Port(1,2,3,4))
!S33(Full 4 Port(1,2,3,4))
!S34(Full 4 Port(1,2,3,4))
!S41(Full 4 Port(1,2,3,4))
!S42(Full 4 Port(1,2,3,4))
!S43(Full 4 Port(1,2,3,4))
!S44(Full 4 Port(1,2,3,4))
!S4P File: Measurements: <S11,S12,S13,S14>,
!<S21,S22,S23,S24>,
!<S31,S32,S33,S34>,
!<S41,S42,S43,S44>:
# Hz S  dB  R 50
! Worked out from all points (4-port):
!   201 points, 10 MHz to 67 GHz, reference 50 ohm
!   strongest paths, dB at 10 MHz, 16.76 GHz, 33.51 GHz, 50.25 GHz, 67 GHz:
!     S43: -0.1, -6.8, -13.4, -21.6, -52.1
!     S21: -0.1, -6.9, -14.2, -24.6, -51.9
!     S23: -51.4, -68.4, -57.8, -62.1, -49.1
!     S41: -52.6, -68.0, -63.9, -49.4, -58.3
!     S42: -58.7, -75.4, -61.5, -56.0, -56.4
!     S31: -50.1, -73.0, -59.3, -55.7, -54.0
!   lowest |S11| = -47.8 dB at 2.02 GHz (marker M1), VSWR 1.01, Z = 50.2 + j0.381 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11  S43  S21  S23  S41  S42  S31
! 10 MHz  -35.8  -0.1  -0.1  -51.4  -52.6  -58.7  -50.1
! 2.02 GHz  -47.8  -0.9  -0.9  -77.3  -69.7  -75.6  -71.7
! 5.034 GHz  -17.5  -2.2  -2.3  -77.4  -69.9  -77.4  -84.3
! 20.44 GHz  -26.3  -8.3  -8.6  -69.6  -69.2  -67.5  -80.5
! 22.79 GHz  -23.6  -9.2  -9.6  -62.6  -68.0  -75.0  -65.3
! 44.22 GHz  -20.7  -18.3  -19.7  -55.9  -57.2  -60.3  -57.0
! 67 GHz  -15.8  -52.1  -51.9  -49.1  -58.3  -56.4  -54.0
